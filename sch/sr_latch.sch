v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {nand2.sym} -120 -80 0 0 {name=x1}
C {nand2.sym} -120 60 0 0 {name=x2}
C {lab_pin.sym} -270 -80 0 0 {name=p1 sig_type=std_logic lab=sbar}
C {lab_pin.sym} -270 -60 0 0 {name=p2 sig_type=std_logic lab=qbar}
C {lab_pin.sym} 30 -100 0 1 {name=p3 sig_type=std_logic lab=q}
C {lab_pin.sym} -630 -130 0 1 {name=p4 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 30 40 0 1 {name=p5 sig_type=std_logic lab=qbar}
C {lab_pin.sym} -270 80 0 0 {name=p6 sig_type=std_logic lab=q}
C {lab_pin.sym} -270 60 0 0 {name=p7 sig_type=std_logic lab=rbar}
C {lab_pin.sym} -270 -100 0 0 {name=p8 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -270 40 0 0 {name=p9 sig_type=std_logic lab=vdd}
C {ipin.sym} -630 -190 0 0 {name=p10 lab=rbar}
C {ipin.sym} -630 -160 0 0 {name=p11 lab=sbar}
C {ipin.sym} -630 -130 0 0 {name=p12 lab=vdd}
C {opin.sym} -650 -90 0 0 {name=p13 lab=q}
C {opin.sym} -650 -60 0 0 {name=p14 lab=qbar}
C {lab_pin.sym} -650 -90 0 0 {name=p15 sig_type=std_logic lab=q}
C {lab_pin.sym} -650 -60 0 0 {name=p16 sig_type=std_logic lab=qbar}
