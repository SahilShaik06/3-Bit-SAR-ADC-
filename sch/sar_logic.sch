v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} -24960 3600 0 0 {name=p1 lab=clk
}
C {ipin.sym} -24970 3660 0 0 {name=p2 lab=reset_neg
}
C {ipin.sym} -24970 3730 0 0 {name=p3 lab=start
}
C {ipin.sym} -24990 3810 0 0 {name=p4 lab=comp_out}
C {opin.sym} -24710 3600 0 0 {name=p5 lab=dac[2:0]}
C {opin.sym} -24710 3660 0 0 {name=p6 lab=result[2:0]}
C {opin.sym} -24700 3710 0 0 {name=p7 lab=done}
